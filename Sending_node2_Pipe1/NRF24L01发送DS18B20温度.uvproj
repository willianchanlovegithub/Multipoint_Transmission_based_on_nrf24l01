# Keil uVision project NRF24L01发送DS18B20温度.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: NRF24L01发送DS18B20温度 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include;.\source
  group Source Group 1
    ./: main.c
    ./source/: DS18B20.c LCD1602.c NRE24L01.c
